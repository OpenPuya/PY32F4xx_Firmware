# Keil uVision project Project.uvprojx, settings and files
target PY32F403xD_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PUYA\PY32F403\Include;..\..\..\Drivers\PY32F403_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Common
    ./: startup_py32f403xx.s
    ../Src/: system_py32f403.c
  group Application/User
    ../Src/: main.c py32f403_hal_msp.c py32f403_it.c
  group Drivers/PY32F403_HAL_Driver
    ../../../Drivers/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_gpio.c py32f403_hal_dma.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_cortex.c
  group Doc
    ../: readme.txt
target PY32F403xC_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xC Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F403xC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target PY32F403xB_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xB Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F403xB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0
