# IAR project Project.ewp, settings and files
configuration PY32F403xD_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F403xD Puya PY32F403xD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; PY32F403xD
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PUYA\PY32F403\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F403_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f403xD_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F403xC_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F403xC Puya PY32F403xC
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; PY32F403xC
  ILINK.IlinkIcfFile: py32f403xC_flash.icf
configuration PY32F403xB_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F403xB Puya PY32F403xB
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; PY32F403xB
  ILINK.IlinkIcfFile: py32f403xB_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f403.c
  group Drivers/PY32F403_HAL_Driver
    ../../../Drivers/PY32F403_HAL_Driver/Src/: py32f403_ll_utils.c
  group Example/EWARM
    ./: startup_py32f403xx.s
  group Example/User
    ../Src/: main.c py32f403_it.c
