# Keil uVision project Project.uvprojx, settings and files
target PY32F403xD_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F403xD,USE_FULL_LL_DRIVER
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F403_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PUYA\PY32F403\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Common
    ../Src/: system_py32f403.c
    ./: startup_py32f403xx.s
  group Application/User
    ../Src/: main.c py32f403_it.c
  group Drivers/PY32F403_HAL_Driver
    ../../../Drivers/PY32F403_HAL_Driver/Src/: py32f403_ll_utils.c
  group Doc
    ../: readme.txt
target PY32F403xC_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xC Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F403xC,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target PY32F403xB_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xB Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F403xB,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
