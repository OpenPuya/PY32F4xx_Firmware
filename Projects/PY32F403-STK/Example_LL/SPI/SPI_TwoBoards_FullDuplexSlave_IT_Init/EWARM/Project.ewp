# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F403xD Puya PY32F403xD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PY32F403xD; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F403xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32F403\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F403_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f403xD_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/PY32F403xx_Start_Kit/: py32f403xx_ll_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f403.c
  group Drivers/PY32F403_HAL_Driver
    ../../../../../../Drivers/PY32F403_HAL_Driver/Src/: py32f403_ll_utils.c py32f403_ll_dma.c py32f403_ll_gpio.c py32f403_ll_rcc.c py32f403_ll_spi.c
  group Example/EWARM
    ./: startup_py32f403xx.s
  group Example/User
    ../Src/: main.c py32f403_it.c
