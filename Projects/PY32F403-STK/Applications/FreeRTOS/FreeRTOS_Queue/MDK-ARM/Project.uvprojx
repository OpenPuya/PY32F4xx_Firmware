# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F403xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32F4xx\Include;..\..\..\..\..\..\Drivers\PY32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Common
    ./: startup_py32f403xx.s
    ../Src/: system_py32f4xx.c
  group Application/User
    ../Src/: main.c py32f4xx_hal_msp.c py32f4xx_it.c py32f4xx_hal_timebase_tim.c
  group BSP/py32f403xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F403xx_Start_Kit/: py32f403xx_Start_Kit.c
  group Drivers/PY32F4xx_HAL_Driver
    ../../../../../../Drivers/PY32F4xx_HAL_Driver/Src/: py32f4xx_hal.c py32f4xx_hal_rcc.c py32f4xx_hal_rcc_ex.c py32f4xx_hal_gpio.c py32f4xx_hal_dma.c py32f4xx_hal_pwr.c py32f4xx_hal_pwr_ex.c py32f4xx_hal_uart.c py32f4xx_hal_cortex.c py32f4xx_hal_flash.c py32f4xx_hal_usart.c py32f4xx_hal_tim.c py32f4xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
